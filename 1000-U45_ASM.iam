# Autodesk Inventor assembly: 1000-U45_ASM
## iProperties
Created: 2006-10
Part Number: 1000-U45_ASM
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles

# Autodesk Inventor assembly: 21.9301 Panel Wingknob
## iProperties
Created: 2006-10
Part Number: 21.9301 Panel Wingknob
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
